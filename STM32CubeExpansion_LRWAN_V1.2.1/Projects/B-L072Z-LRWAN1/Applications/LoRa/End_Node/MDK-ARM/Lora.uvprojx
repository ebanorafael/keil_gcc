# Keil uVision project Lora.uvprojx, settings and files
target mlm32l07x01 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IROM(0x08000000,0x00030000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Lora
  AfterMake: "C:\Program Files (x86)\GNU Tools Arm Embedded\7 2018-q2-update\bin\arm-none-eabi-size.exe" -B -d ./Objects/Lora.elf
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/sx1276/: sx1276.c
  group Drivers/BSP/CMWX1ZZABZ-0xx
    ../../../../../../Drivers/BSP/CMWX1ZZABZ-0xx/: mlm32l07x01.c
  group B-L072Z-LRWAN1
    ../../../../../../Drivers/BSP/B-L072Z-LRWAN1/: b-l072z-lrwan1.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_adc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c.c
  group Projects/MDK-ARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/gcc/: startup_stm32l072xx.s
  group Projects/End_Node
    ../LoRaWAN/App/src/: bsp.c debug.c hw_gpio.c hw_rtc.c hw_spi.c main.c vcom.c
    ../Core/src/: mlm32l0xx_hal_msp.c mlm32l0xx_hw.c mlm32l0xx_it.c
  group Middlewares/LoRaWAN/Core
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Core/: lora.c lora-test.c
  group Middlewares/LoRaWAN/Mac
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/: LoRaMac.c LoRaMacCrypto.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacFCntHandler.c LoRaMacParser.c LoRaMacSerializer.c LoRaMacAdr.c
  group Middlewares/LoRaWAN/Mac/Regions
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionRU864.c
  group Middlewares/LoRaWAN/Utilities
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Utilities/: low_power_manager.c timeServer.c utilities.c queue.c trace.c systime.c
  group Middlewares/LoRaWAN/Crypto
    ../../../../../../Middlewares/Third_Party/LoRaWAN/Crypto/: aes.c cmac.c soft-se.c
